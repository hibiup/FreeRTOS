# Keil uVision project HelloRTOS.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.4.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: HelloRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\FreeRTOS\Source\include;.\FreeRTOS\Source\portable\RVDS\ARM_CM3
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group FreeRTOS/Source
    ./FreeRTOS/Source/: list.c
  group User
    ./User/: main.c
  group Doc
    ./Doc/: README.md
software components: CMSIS:CORE 5.1.2, Device:Startup 1.0.1
